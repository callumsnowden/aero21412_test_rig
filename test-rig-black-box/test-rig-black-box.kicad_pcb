# Repository callumsnowden/aero21412_test_rig

File README.md:

# aero21412_test_rig
AERO21412 Avionics Coursework 1 – Wind Tunnel Test Rig "Black Box"

## Description
A "black box" PCB that provides the interface between a number of sensors on the wind tunnel test rig and an external data acquisition system.The aim is to provide a number of outputs measuring supply voltage and current; motor torque, thrust and rotational speed. A PWM input signal should be provided that is passed directly to the ESC module.

## Signals to/from DAS
- [] RPM as voltage with scaling factor
- [] Scaled supply voltage
- [] Supply current as voltage with scaling factor
- [] UART for force measurements (optional control input)

## UART measurement packet specification

`<AAA,BB.BBB,CC.CCC>`

Measurements are transmitted at 20 Hz. The packet consists of a start character of `<` followed by an incrementing three-digit frame identifier `AAA`. After this follows a three decimal place measurement of thrust in Newtons `BB.BBB` and then a three decimal place measurement of torque in Newton metres `CC.CCC`. An end character `>` terminates the packet.

## Hardware

A Raspberry Pi Pico (RP2040) handles interfacing the load cells and photointerruptor and is responsible for transmitting UART messages plus generating an analogue voltage representing RPM.

### Sensors

- One load cell for thrust measurement (Siemens 7MH5102-1PD00) with a rated load of 5kg
- One load cell (analogue voltage output) for torque measurement (TE Connectivity FC2231-0000-0010-L) with a rated load of 10lbf (13.5 Nm) and a voltage output of 0.5-4.5V
- Photointerruptor for RPM measurement

## KiCad design test-rig-black-box/test-rig-black-box.kicad_pcb

Parts:
C1, C6, C9, C10, C13, C14, C16, C17: 1uF; C_0603_1608Metric; ManufacturerPartNumber CL10A105KA8NNNC
C2, C3, C5, C8, C11, C12, C15: 0.1uF; C_0603_1608Metric; ManufacturerPartNumber C0603C104Z3VAC7411
C4, C7: 10uF; C_0603_1608Metric; ManufacturerPartNumber CL10A106MP8NNNC
C18: 22uF; CP_Elec_6.3x5.7; ManufacturerPartNumber A768EB226M1HLAE048
C19: 47uF; CP_Elec_6.3x5.7; ManufacturerPartNumber A768EB476M1VLAE042
D1, D2, D4, D5: SMAJ5.0A/TR13; D_SMA; ManufacturerPartNumber SMAJ5.0A/TR13
D3, D6, D8: CDSOT23-T05C; SOT-23; ManufacturerPartNumber CDSOT23-T05C
D7: Green; D_0603_1608Metric; ManufacturerPartNumber KT EELP41.12-S2U1-25-2X4X-5-R18
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J3, J8: Conn_01x04; Molex_KK-254_AE-6410-04A_1x04_P2.54mm_Vertical; ManufacturerPartNumber 22-27-2041
J2: Conn_01x15; DSUB-15_Female_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_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; ManufacturerPartNumber 5504F1-15S-02-03-F1
J4: XT60-M; AMASS_XT60-M_1x02_P7.20mm_Vertical; ManufacturerPartNumber XT60-M
J5: XT60-F; AMASS_XT60-F_1x02_P7.20mm_Vertical; ManufacturerPartNumber XT60-F
J6: Molex 22-27-2031; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical; ManufacturerPartNumber 22-27-2031
J7: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical; ManufacturerPartNumber 2211S-03G
J9: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical; ManufacturerPartNumber 2213S-10G
JP1: 3p jumper; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm_NumberL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
L2: 3.3uH; L_0603_1608Metric; ManufacturerPartNumber 742792656
Q1: MMBT4403; SOT-23; ManufacturerPartNumber MMBT4403LT1G
Q2: 2N7002BK,215; SOT-23; ManufacturerPartNumber 2N7002BK,215
Q3: NX3008PBK,215; SOT-23; ManufacturerPartNumber NX3008PBK,215
R1, R2: 100R; R_0603_1608Metric; ManufacturerPartNumber RCA0603100RFKEA
R3, R4, R7, R10, R18, R19: 3.3K; R_0603_1608Metric; ManufacturerPartNumber RC0603FR-133K3L
R5, R8: 20K; R_0603_1608Metric; ManufacturerPartNumber RC0603FR-1320KL
R6: 8.2K; R_0603_1608Metric; ManufacturerPartNumber RC0603JR-078K2L
R9: 110R; R_0805_2012Metric; ManufacturerPartNumber RC0805FR-07110RL
R11: 1.6K; R_0603_1608Metric; ManufacturerPartNumber RC0603FR-071K6L
R12: 5.1K; R_0603_1608Metric; ManufacturerPartNumber AC0603FR-135K1L
R13: 9.76K; R_0603_1608Metric; ManufacturerPartNumber ERJ3EKF9761V
R14: 10K; R_0603_1608Metric; ManufacturerPartNumber RK73B1JTTD103J
R15: 2K; R_0603_1608Metric; ManufacturerPartNumber RK73H1JTTD2001F
R16, R17, R20, R21: 1K; R_0603_1608Metric; ManufacturerPartNumber RK73H1JTTD1001F
SW1: SW_Push; SW_PUSH_6mm; ManufacturerPartNumber FSM4JH
U1: Pico; RPi_Pico_SMD_TH; ManufacturerPartNumber Pico
U2: ADS1100; SOT-23-6; ManufacturerPartNumber ADS1100A3IDBVT
U3: HX711; SOP-16_3.9x9.9mm_P1.27mm; ManufacturerPartNumber HX711
U4: TXU0202DCUR; VSSOP-8_2.3x2mm_P0.5mm; ManufacturerPartNumber TXU0202DCUR
U5, U7: LMV321; SOT-23-5; ManufacturerPartNumber LMV321IDBVR
U6: ACS724LLCTR-50AB-S; SOIC-8_3.9x4.9mm_P1.27mm; ManufacturerPartNumber ACS724LLCTR-50AB-S
U8: TR05S05; TR05Sxx; ManufacturerPartNumber TR05S05

Connections:
+3V3: C6.1, C9.1, J9.9, JP1.1 (A), R3.1, R4.1, R8.2, R10.2, U1.36 (3V3), U3.16 (DVDD), U4.3 (VCCA), U4.6 (OE)
+5V: C1.1, C7.1, C8.1, C13.1, C16.1, C17.1, C19.1, J6.1, J8.1, J9.8, JP1.3 (B), Q1.2 (E), Q3.2 (S), R9.2, R19.2, U1.39 (VSYS), U2.5 (VDD), U3.1 (VSUP), U5.5 (V+), U7.5 (V+), U8.3 (+Vout)
/CURRENT_SENSE_EN: J2.7, Q2.1 (G), R18.2
/GP5: J9.1, U1.7 (GPIO5)
/GP10: J9.2, U1.14 (GPIO10)
/GP11: J9.3, U1.15 (GPIO11)
/GP12: J9.4, U1.16 (GPIO12)
/GP13: J9.5, U1.17 (GPIO13)
/GP14: J9.6, U1.19 (GPIO14)
/GP15: J9.7, U1.20 (GPIO15)
/HX711_CLK: U1.9 (GPIO6), U3.11 (PD_SCK)
/HX711_DATA: U1.10 (GPIO7), U3.12 (DOUT)
/I2C0_SCL: D6.1 (A1), J8.2, R4.2, U1.12 (GPIO9), U2.3 (SCL)
/I2C0_SDA: D6.2 (A2), J8.3, R3.2, U1.11 (GPIO8), U2.4 (SDA)
/I2C_SLAVE_SCL: D8.1 (A1), J2.1, U1.25 (GPIO19)
/I2C_SLAVE_SDA: D8.2 (A2), J2.2, U1.24 (GPIO18)
/I_SENSE: D4.1 (A1), J2.8, R21.2
/TACHO_IN: D1.1 (A1), J3.3, R10.1, U1.5 (GPIO3)
/TACHO_VOLTAGE_PWM: R11.1, U1.6 (GPIO4)
/UART0_RX: U1.2 (GPIO1), U4.4 (A2Y)
/UART0_TX: U1.1 (GPIO0), U4.5 (A1)
/V_SENSE: J2.5, R14.2, R15.1
/ZERO_BTN: C11.2, R7.2, U1.4 (GPIO2)
GND: C1.2, C2.1, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.1, C12.1, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, D1.2 (A2), D2.2 (A2), D3.3 (common), D4.2 (A2), D5.2 (A2), D6.3 (common), D8.3 (common), J1.4, J2.4, J2.6, J2.9, J2.12, J3.2, J3.4, J4.1, J5.1, J6.3, J7.1, J8.4, J9.10, Q2.2 (S), R6.1, R13.1, R15.2, R17.2, R18.1, SW1.1, U1.3 (GND), U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U1.33 (AGND), U1.38 (GND), U1.42 (GND), U2.2 (GND), U2.6 (VIN-), U3.5 (AGND), U3.14 (XI), U3.15 (RATE), U4.2 (GND), U5.2 (V-), U6.5 (GND), U7.2 (V-), U8.2 (GND)
unnamed: D2.1 (A1), J2.3, R20.2
unnamed: D3.1 (A1), J2.10, U4.8 (B1Y)
unnamed: D3.2 (A2), J2.11, U4.1 (B2)
unnamed: D5.1 (A1), J6.2, R16.1
unnamed: D7.2 (A), U1.21 (GPIO16)
unnamed: D7.1 (K), R17.1
unnamed: C4.1, C5.1, J1.1, L2.1
unnamed: J1.2, R1.1
unnamed: J1.3, R2.1
unnamed: J2.13, J7.2
unnamed: J2.14, J7.3
unnamed: J3.1, R9.1
unnamed: C18.1, J4.2, R14.1, U6.1 (IP+), U6.2 (IP+), U8.1 (+Vin)
unnamed: J5.2, U6.3 (IP-), U6.4 (IP-)
unnamed: C10.1, JP1.2 (C), U4.7 (VCCB)
unnamed: Q1.1 (B), U3.2 (BASE)
unnamed: L2.2, Q1.3 (C), R5.2, U3.3 (AVDD)
unnamed: Q2.3 (D), Q3.1 (G), R19.1
unnamed: C14.1, Q3.3 (D), U6.8 (VCC)
unnamed: R7.1, R8.1, SW1.2
unnamed: R12.2, R20.1, U5.4
unnamed: R16.2, U2.1 (VIN+)
unnamed: C3.2, R1.2, U3.8 (INA+)
unnamed: C3.1, R2.2, U3.7 (INA-)
unnamed: C2.2, U3.6 (VBG)
unnamed: R5.1, R6.2, U3.4 (VFB)
unnamed: C12.2, R11.2, U5.1 (+)
unnamed: R12.1, R13.2, U5.3 (-)
unnamed: C15.1, U6.6 (FILTER)
unnamed: U6.7 (VIOUT), U7.1 (+)
unnamed: R21.1, U7.3 (-), U7.4

Notes on the sheet:
GPIO exp.
Amplifies 0-3.3V to 0-5V range
ESC
I2C exp.

Board: 4 copper layers, 75.0 x 100.0 mm, 102 parts (0 on the bottom side), 55 nets.

Other parts of the board:
kibuzzard-672A2B3E: G***; kibuzzard-672A2B3E
kibuzzard-672A2B23: G***; kibuzzard-672A2B23
kibuzzard-671770C0: G***; kibuzzard-671770C0
kibuzzard-671770F1: G***; kibuzzard-671770F1
kibuzzard-671770F6: G***; kibuzzard-671770F6
kibuzzard-671771D1, kibuzzard-671771D1#2: G***; kibuzzard-671771D1
kibuzzard-671771D9, kibuzzard-671771D9#2: G***; kibuzzard-671771D9
kibuzzard-671771E1: G***; kibuzzard-671771E1
kibuzzard-671772CC: G***; kibuzzard-671772CC
kibuzzard-671772D6: G***; kibuzzard-671772D6
kibuzzard-671773D8: G***; kibuzzard-671773D8
kibuzzard-671775A0: G***; kibuzzard-671775A0
kibuzzard-6717711C: G***; kibuzzard-6717711C
kibuzzard-6717717D: G***; kibuzzard-6717717D
kibuzzard-6717758B: G***; kibuzzard-6717758B
kibuzzard-67177092: G***; kibuzzard-67177092
kibuzzard-67177102: G***; kibuzzard-67177102
kibuzzard-67177109: G***; kibuzzard-67177109
kibuzzard-67177114: G***; kibuzzard-67177114
kibuzzard-67177127: G***; kibuzzard-67177127
kibuzzard-67177131: G***; kibuzzard-67177131
kibuzzard-67177240: G***; kibuzzard-67177240
kibuzzard-67177262: G***; kibuzzard-67177262
kibuzzard-67177297: G***; kibuzzard-67177297
kibuzzard-67177472: G***; kibuzzard-67177472

## Commit log

2024-10-18 Start work on PCB layout
2024-11-21 v0.1 PCB design
    - Added gerbers
    - BOM generated
2024-12-03 Fix orientation of TVS diodes
2024-12-03 Start firmware work
2024-12-10 Change firmware, start documentation work
    - Removed C based firmware in favour of MicroPython
    - Started work on user guide
2025-01-09 Update board to v0.2
    - Fix issue with regulator footprint being wrong
    - Fix issue with TVS diodes being the wrong way around
    - Added soldermask over jumper for selecting 3V3/5V UART
2025-01-14 Create MainAssembly.stp
    Added STEP file for test rig assembly.
2025-03-21 Minor code updates
    - Add utility functions for board test
    - Change debug serial output to RPM rather than frequency
    - Update maximum motor speed
    - Add note about copying over the hx711-pico-mpy source
